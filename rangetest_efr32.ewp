# IAR project rangetest_efr32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32FG1P133F256GM48 SiliconLaboratories EFR32FG1P133F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32FG1P133F256GM48; RETARGET_VCOM; CONFIGURATION_HEADER="rail-configuration.h"; BOARD_BRD4250A
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/CMSIS/include; ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/Device/SiliconLabs/EFR32FG1P/Include; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\memory_manager; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\command_interpreter; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\rtcdrv\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\ustimer\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\gpiointerrupt\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\common\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emlib\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\kits\common\bsp; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\kits\common\drivers; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\hal\efr32; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\rail_lib\common; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\apps\rangetest\config; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\apps\rangetest; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\spidrv\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\dmadrv\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\uartdrv\inc; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\reptile\glib; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\reptile\glib\glib; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\reptile\glib\dmd; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\response_print; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\rail_lib\chip\efr32; ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\kits\EFR32FG1_BRD4250A\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rangetest.bin
  ILINK.IlinkOutputFile: rangetest.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\autogen\librail_release\librail_efr32_iar_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32FG1P133F256GM48; RETARGET_VCOM; CONFIGURATION_HEADER="rail-configuration.h"; BOARD_BRD4250A
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/hal/efr32/: hal_efr.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/hal/: hal_common.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/dmadrv/src/: dmadrv.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/uartdrv/src/: uartdrv.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/ustimer/src/: ustimer.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/kits/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c dmactrl.c retargetio.c retargetserial.c udelay.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/reptile/glib/dmd/display/: dmd_display.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/reptile/glib/glib/: glib.c glib_bitmap.c glib_font_narrow_6x8.c glib_font_normal_8x8.c glib_line.c glib_rectangle.c glib_string.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/command_interpreter/: command_interpreter.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/memory_manager/: buffer_pool_allocator.c rail_integration.c
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/response_print/: response_print.c
    ./: graphics.c menu.c pushButton.c rail-callback-stubs.c rail-callbacks.c rail_config.c rangeTest.c rangetestconfig.c seq.c
  group CMSIS
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/Device/SiliconLabs/EFR32FG1P/Source/IAR/: startup_efr32fg1p.s
    ../../../../../SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/Device/SiliconLabs/EFR32FG1P/Source/: system_efr32fg1p.c
